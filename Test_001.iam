# Autodesk Inventor assembly: Test_001
## iProperties
Created: 2009-08
Part Number: Test_001
Document SubType Name: Assembly
Designer: 10172392
Author: 10172392
